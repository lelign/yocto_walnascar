FILESEXTRAPATHSprepend := "${THISDIR}:"
SRC_URI += "file://this.patch"
#PR := "${@int(PR) + 1}"