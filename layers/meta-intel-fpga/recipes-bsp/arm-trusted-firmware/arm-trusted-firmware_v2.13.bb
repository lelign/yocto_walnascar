require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=6ed7bace7b0bc63021c6eba7b524039e"

ATF_VERSION = "v2.13.0"
ATF_BRANCH = "socfpga_${ATF_VERSION}"

SRCREV = "743e349d03b65724a1635d0833a2bef18c9f79a6"
