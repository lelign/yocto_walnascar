require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2024.04"

SRCREV = "698d4137f7712e99eeff4ed844b774342457f13a"
